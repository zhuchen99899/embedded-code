# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Main +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MALLOC;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SRAM;..\HARDWARE\TOUCH;..\HARDWARE\W25QXX;..\EMWIN\EMWIN_APP;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\HARDWARE\ADC;..\EMWIN\STemWin_Addons;..\HARDWARE\STMFLASH;..\HARDWARE\PWM;..\HARDWARE\WIFI;..\Freertos_task;..\MQTT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c QueueCreate.c tem.c pid.c includes.h SemaphoreCreat.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/PWM/: pwm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_dma.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRtos_task
    ../Freertos_task/: task_led.c task_pwm.c task_adc.c task_MQTT_connect.c task_MQTT_pingreq.c task_MQTT_rec.c task_emwin.c task_userif.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin532_CM3_OS_Keil.lib
  group EMWIN_CONFIG
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_FreeRTOS.c
  group EMWIN_APP
    ../EMWIN/STemWin_Addons/: ST_GUI_Addons.h
    ../EMWIN/EMWIN_APP/: setdialog.c iconvdesk.c ButtonController.c adcgui.c bkjpeg.c setbmp.c returnbmp.c Numpad.c
  group MQTT
    ../MQTT/: MQTTconnect.c MQTTpingreq.c MQTTpacket.c MQTT.h MQTTConfig.h MQTT_init.c
  group README
    ../: README.TXT
